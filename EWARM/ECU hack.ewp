# IAR project ECU hack.ewp, settings and files
configuration ECU hack (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446RE ST STM32F446RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: ECU hack.out
  ILINK.IlinkIcfFile: stm32f446xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Middlewares
    ./: 
  group Middlewares/FreeRTOS
    ./: 
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c tasks.c event_groups.c timers.c queue.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application
    ./: 
  group Application/EWARM
    ./:  startup_stm32f446xx.s
  group Application/User
    ./: 
    ../Src/: stm32f4xx_hal_timebase_TIM.c main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers
    ./: 
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ./: 
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c
